# Keil uVision project homework.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source\inc
  group Source Group 1
    ./source/src/: main.c led.c timer.c key.c
